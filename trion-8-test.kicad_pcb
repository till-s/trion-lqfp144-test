# Repository till-s/trion-lqfp144-test

File README.md:

# Efinix Trion JTAG Programmer and Evaluation Board

This board implements a JTAG programmer that can be used with
the efinity software to access [efinix](https://www.efinixinc.com)
FPGAs via JTAG.

The board also hosts a Trion T8Q144 device (pin-compatible with
the more loaded T20Q144 which could be used as an alternative),
ULPI and full-speed PHYs and a bunch of LEDs/GPIOs.

I have used this board successfully to exercise the
[mecatica-usb](https://www.github.com/till-s/mecatica-usb) with
trion devices.

The programmer is connected to the trion's JTAG port with a
flat ribbon cable which makes it possible to use the PCB
as a programmer for other boards with an Efinix FPGA.

## Programmer-only Mode

It is possible to partially load the board if you are only looking
for a programmer.

 - load everything on the FT-USB-JTAG sheet
 - load the 3V3 converter (U12) and associated components
   on the Power sheet. You can omit U6 and everything associated
   with it.
 - However, make sure you *do load* R56 (may be a zero-Ohm jumper
   if U6 is omitted) in order to enable the 3V3 converter.

## KiCad design trion-8-test.kicad_pcb

Board: 4 copper layers, 100.0 x 82.9 mm, 209 parts (44 on the bottom side), 180 nets.

Parts:
BT1: Battery_Cell; bh-3034-74-combined
C1, C2, C3, C4, C5, C6, C7, C8, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C24, C25, C26, C28, C29, C31, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C47, C48, C51, C55, C56, C57, C59, C64, C73, C74, C75, C76, C79, C80: 100n; C_0603_1608Metric
C9, C10, C23, C27, C30, C32, C46, C81, C83: 4u7; C_0805_2012Metric
C21, C22, C45, C61, C62, C63, C68, C72: 10u; C_1206_3216Metric
C49, C50: 1u; C_0603_1608Metric
C52, C53: 10p; C_0603_1608Metric
C54: 10n; C_0603_1608Metric
C58, C60: 1n; C_0603_1608Metric
C65, C66, C67, C69, C70, C71: 1u; C_0805_2012Metric
C77, C78, C82: 50p; C_0603_1608Metric
D1, D2, D3, D4, D5: LED_Dual_RAG; LED_Wuerth_Sideview
D11: LED-GRN; LED_0603_1608Metric
D12: D; D_SOD-323F
D13: D_SOD-882
H1, H2, H3, H4: Foot FF-13-P3.5X5.5B; foot_ff-13
J1: RJ45_Amphenol_RJMG1BD3B8K1ANR
J2: GPS_GPIO; PinHeader_2x04_P2.54mm_Vertical
J3: T8_JTAG; PinHeader_2x07_P2.00mm_Vertical
J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Molex_2171790001_16P_TopMnt_Horizontal
J5: ETH GPIO; PinHeader_2x10_P2.54mm_Vertical
J6: FPGA GPIO; PinHeader_2x10_P2.54mm_Vertical
J8: Antenna; SMA Molex 732515460
J9: Geofnc; PinSocket_1x02_P2.54mm_Vertical
J10: PPS; LEMO+SMA_molex_732515460
J11: IO1; LEMO+SMA_molex_732515460
J12: IO2; LEMO+SMA_molex_732515460
J13: IO3; LEMO+SMA_molex_732515460
J14: IO4; LEMO+SMA_molex_732515460
J15: IO8; LEMO+SMA_molex_732515460
J16: CLK; LEMO+SMA_molex_732515460
JP1, JP2: 2k2; J_0603_I
JP3, JP4, JP5: 2k2; J_0603_L
JP6: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
JP7: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
L1, L2, L3, L4, L5: 600Ohm@100MHz; L_0603_1608Metric
L6, L7: 1u5; L_1008_2520Metric
L8: 100n; L_0402_1005Metric
Q1: SSM3K37MFV; SOT-723
R1, R22, R23, R24, R30, R31, R32, R33, R34, R36, R37, R39, R40, R41, R42, R43, R46, R48, R58, R59, R60: 10k; R_0603_1608Metric
R2, R3, R4, R5: 50; R_0603_1608Metric
R6, R7: 680; R_0603_1608Metric
R8, R51, R57, R65, R66, R67, R68, R69, R70, R71, R72: 1k; R_0603_1608Metric
R9, R10, R16, R20, R29, R38, R49, R62, R63: 0; R_0603_1608Metric
R11, R12, R14, R15, R17, R18, R19, R25, R26, R27, R28: 2k2; R_0603_1608Metric
R13: 210; R_0603_1608Metric
R21: 1k5; R_0603_1608Metric
R35, R56: 100k; R_0603_1608Metric
R44, R45: 5k1; R_0603_1608Metric
R47: 8k06; R_0603_1608Metric
R50, R73: 1M; R_0603_1608Metric
R53: 4k87; R_0603_1608Metric
R61: 45k3; R_0603_1608Metric
SW1: Reconfig; SW_SPST_PTS810_and_PTS841
U1: NDS36PT5-16ET; TSOP-II-54_22.2x10.16mm_P0.8mm
U2: dp83640; LQFP-48_7x7mm_P0.5mm
U3: LC76G; lc76g
U4: TS5A63157DBV; SOT-23-6
U6, U12: RT8096B; SOT-23-6
U8: T20Q144xx; LQFP-144_20x20mm_P0.5mm
U9: AT25FF081A-SSHN-B; SOIC-8_3.9x4.9mm_P1.27mm
U10: USB3343; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
X1, X2: ECS-2520MV-250-CM; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm
Y1: 26MHz; Crystal_SMD_Abracon_ABM10-4Pin_2.5x2.0mm

Connections:
+1V2: C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C65.1, C66.1, C67.1, C68.1, L3.1, L4.1, L5.1, R62.2, U8.13 (VCC), U8.22 (VCC), U8.49 (VCC), U8.57 (VCC), U8.85 (VCC), U8.96 (VCC), U8.125 (VCC), U8.128 (VCC), U8.130 (VCC)
+3V3: C3.1, C6.1, C7.1, C8.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C23.1, C24.1, C25.1, C26.1, C42.1, C43.1, C44.1, C51.2, C57.1, C59.1, C64.1, C69.1, C70.1, C71.1, C72.1, C74.1, C75.1, C79.1, C81.1, C82.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), J1.R4 (TCT), J1.R5 (RCT), J2.8, J5.2, J5.20, J6.2, J6.20, JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP7.3 (B), L1.2, L2.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.2, R7.2, R8.1, R11.2, R12.2, R14.1, R15.1, R17.2, R18.2, R19.2, R21.2, R22.1, R23.1, R24.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1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
+5V: C21.1, C22.1, C48.1, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), R46.1, R56.1, U6.1 (EN), U6.4 (VIN), U10.16 (VBAT), U12.4 (VIN)
/GPS/RF_IN: D13.2 (A2), J8.1 (In), L8.1, U3.11 (RF_IN)
/sdram/A0: U1.23 (A0), U8.144 (GPIOL_64)
/sdram/A1: U1.24 (A1), U8.139 (GPIOL_68)
/sdram/A2: U1.25 (A2), U8.140 (GPIOL_67_CDI13)
/sdram/A3: U1.26 (A3), U8.141 (GPIOL_65)
/sdram/A6: U1.31 (A6), U8.106 (GPIOR_94_CDI27)
/sdram/A7: U1.32 (A7), U8.105 (GPIOR_95_CDI26)
/sdram/A8: U1.33 (A8), U8.103 (GPIOR_104_CDI25)
/sdram/A9: U1.34 (A9), U8.102 (GPIOR_105_CDI24)
/sdram/A10: U1.22 (A10), U8.142 (GPIOL_66_CDI12)
/sdram/BA0: U1.20 (BA0), U8.4 (GPIOL_54_CDI11)
/sdram/BA1: U1.21 (BA1), U8.3 (GPIOL_53_CDI10)
/sdram/CASb: U1.17 (~CAS), U8.8 (GPIOL_40_CDI8)
/sdram/CLK: U1.38 (CLK), U8.98 (GPIOR_117_CTRL14)
/sdram/CSb: R1.2, U1.19 (~CS), U8.6 (GPIOL_46)
/sdram/DQ1: U1.4 (DQ1), U8.20 (GPIOL_12_CDI2)
/sdram/DQ2: U1.5 (DQ2), U8.19 (GPIOL_13_CDI3)
/sdram/DQ3: U1.7 (DQ3), U8.18 (GPIOL_20_CTRL0_CDI4)
/sdram/DQ4: U1.8 (DQ4), U8.17 (GPIOL_21_CTRL1_CDI5)
/sdram/DQ5: U1.10 (DQ5), U8.16 (GPIOL_22_CTRL2)
/sdram/DQ6: U1.11 (DQ6), U8.15 (GPIOL_24_CLK0)
/sdram/DQ7: U1.13 (DQ7), U8.14 (GPIOL_25_CLK1)
/sdram/DQ8: U1.42 (DQ8), U8.100 (GPIOR_113_CDI22)
/sdram/DQ9: U1.44 (DQ9), U8.99 (GPIOR_116_CTRL15)
/sdram/DQ10: U1.45 (DQ10), U8.97 (GPIOR_122_CLK13_CDI21)
/sdram/DQ11: U1.47 (DQ11), U8.87 (GPIOR_132_CDI19)
/sdram/DQ12: U1.48 (DQ12), U8.86 (GPIOR_133_CDI18)
/sdram/DQ13: U1.50 (DQ13), U8.81 (GPIOR_139)
/sdram/DQ14: U1.51 (DQ14), U8.77 (GPIOR_154)
/sdram/DQ15: R30.2, U1.53 (DQ15), U8.74 (GPIOR_158_TEST_N)
/sdram/DQMH: U1.39 (DQMH), U8.101 (GPIOR_112_CDI23)
/sdram/DQML: U1.15 (DQML), U8.11 (GPIOL_31_CLK7_CDI6)
/sdram/RASb: U1.18 (~RAS), U8.7 (GPIOL_41_CDI9)
/sdram/WEb: U1.16 (~WE), U8.10 (GPIOL_32_CTRL4_CDI7)
/ulpi/ULPI_D0: U8.124 (GPIOR_76_PLLIN0), U10.4 (DATA0)
/ulpi/ULPI_D1: U8.123 (GPIOR_77_PLLIN1), U10.5 (DATA1)
/ulpi/ULPI_D2: U8.119 (GPIOR_78_EXTFB0_CDI31), U10.6 (DATA2)
/ulpi/ULPI_D3: U8.118 (GPIOR_79_EXTFB1_CDI30), U10.7 (DATA3)
/ulpi/ULPI_D4: U8.117 (GPIOR_80), U10.8 (DATA4)
/ulpi/ULPI_D5: U8.116 (GPIOR_81_MREFCLK), U10.10 (DATA5)
/ulpi/ULPI_D6: U8.115 (GPIOR_82), U10.11 (DATA6)
/ulpi/ULPI_D7: U8.114 (GPIOR_83), U10.12 (DATA7)
/ulpi/ULPI_USB_N: J4.A7 (D-), J4.B7 (D-), U10.14 (DM)
/ulpi/ULPI_USB_P: J4.A6 (D+), J4.B6 (D+), U10.13 (DP)
A11: U1.35 (A11), U8.112 (GPIOR_86)
A12: U1.36 (A12), U8.111 (GPIOR_85)
CKE: U1.37 (CKE), U8.113 (GPIOR_84)
ETH0_CLK_OUT: J5.18, J16.1 (In), U2.24 (CLK_OUT), U8.93 (GPIOR_123_CLK12_CDI20)
ETH0_COL: R11.1, U2.42 (COL), U8.67 (GPIOB_RXP10)
ETH0_CRS_DV: JP5.2 (C), U2.40 (CRS/CRS_DV), U8.69 (GPIOB_RXN12_EXTFB0)
ETH0_GPIO_1: J5.4, J11.1 (In), JP1.2 (C), U2.21 (GPIO1), U8.89 (GPIOR_129_CTRL10)
ETH0_GPIO_2: J5.6, J12.1 (In), JP2.2 (C), U2.22 (GPIO2), U8.90 (GPIOR_128_CTRL11)
ETH0_GPIO_3: J5.8, J13.1 (In), U2.23 (GPIO3)
ETH0_GPIO_4: J5.10, J14.1 (In), U2.25 (GPIO4)
ETH0_GPIO_8: J5.12, J15.1 (In), U2.36 (GPIO8)
ETH0_GPIO_9: J5.14, U2.37 (GPIO9), U8.72 (GPIOB_CLKN0)
ETH0_GPIO_10: J5.16, U2.9 (TDO)
ETH0_LED_ACT: D11.1 (K), R19.1, U2.26 (LED_ACT)
ETH0_LED_LINK: J1.L2, R17.1, U2.28 (LED_LINK)
ETH0_LED_SPEED: J1.L3, R18.1, U2.27 (LED_SPEED/FX_SD)
ETH0_MDC: U2.31 (MDC), U8.48 (GPIOB_TXN09)
ETH0_MDIO: R21.1, U2.30 (MDIO), U8.47 (GPIOB_TXP09)
ETH0_PWRDWN_IRQ: U2.7 (PWRDOWN/INTN), U8.53 (GPIOB_TXP11)
ETH0_RDN: J1.R6 (RD-), R2.2, U2.13 (RD-)
ETH0_RDP: J1.R3 (RD+), R3.2, U2.14 (RD+)
ETH0_REFCLK: R9.2, U2.34 (X1), X1.3 (OUT)
ETH0_RSTb: U2.29 (RESET_N), U8.46 (GPIOB_TXN06)
ETH0_RXD_0: R25.1, U2.46 (RXD_0), U8.60 (GPIOB_RXN03)
ETH0_RXD_1: R26.1, U2.45 (RXD_1), U8.61 (GPIOB_RXP03)
ETH0_RXD_2: R27.1, U2.44 (RXD_2)
ETH0_RXD_3: R28.1, U2.43 (RXD_3)
ETH0_RX_CLK: R9.1, R10.2, U8.71 (GPIOB_CLKP0)
ETH0_RX_DV: JP3.2 (C), U2.39 (RX_DV), U8.70 (GPIOB_RXP12_EXTFB0)
ETH0_RX_ER: R12.1, U2.41 (RX_ER), U8.68 (GPIOB_RXN10)
ETH0_TDN: J1.R2 (TD-), R4.2, U2.16 (TD-)
ETH0_TDP: J1.R1 (TD+), R5.2, U2.17 (TD+)
ETH0_TXD_0: U2.3 (TXD_0), U8.58 (GPIOB_RXP02)
ETH0_TXD_1: U2.4 (TXD_1), U8.56 (GPIOB_RXN00)
ETH0_TXD_3: JP4.2 (C), U2.6 (TXD_3)
ETH0_TX_EN: U2.2 (TX_EN), U8.59 (GPIOB_RXN02)
FPGA_GPIO_0: J6.4, U8.36 (REF_RES)
FPGA_GPIO_1: J6.6, U8.38 (GPIOB_TXP00)
FPGA_GPIO_2: J6.8, U8.39 (GPIOB_TXN00)
FPGA_GPIO_3: J6.10, U8.40 (GPIOB_TXP02)
FPGA_GPIO_4: J6.12, U8.41 (GPIOB_TXN02)
FPGA_GPIO_5: J6.14, U8.54 (GPIOB_TXN11)
FPGA_GPIO_6: J6.16, U8.55 (GPIOB_RXP00)
FPGA_GPIO_7: J6.18, U8.65 (GPIOB_RXN07)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.1, C50.1, C51.1, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2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
GPS_PPS: J2.6, J10.1 (In), U2.12 (TDI), U3.4 (PPS), U8.45 (GPIOB_TXP06)
GPS_RSTb: U3.9 (RESET_N), U8.66 (GPIOB_RXP07)
LED0: R57.1, U8.92 (GPIOR_125_CLK10)
LED1: R65.1, U8.84 (GPIOR_135_CDI17)
LED2: R66.1, U8.83 (GPIOR_136_CDI16)
LED3: R67.1, U8.82 (GPIOR_138)
LED4: R22.2, R68.1, U8.80 (GPIOR_149_CBUS2)
LED5: R23.2, R69.1, U8.79 (GPIOR_150_CBUS1)
LED6: R24.2, R70.1, U8.78 (GPIOR_151_CBUS0)
LED7: R71.1, U8.76 (GPIOR_155)
unnamed: BT1.1 (+), JP7.1 (A)
unnamed: C1.1, C2.1, C4.1, C5.1, C9.1, L1.1, U1.3 (VDDQ), U1.9 (VDDQ), U1.43 (VDDQ), U1.49 (VDDQ)
unnamed: C56.1, C58.1, C60.1, C73.1, J1.R8, J1.SH
unnamed: C61.1, C63.1, L6.1, R60.2, R62.1
unnamed: C62.1, L7.1, R61.2, R63.1
unnamed: C76.1, C77.1, L8.2, R13.1
unnamed: D1.1 (K1), R65.2
unnamed: D1.3 (K2), R57.2
unnamed: D2.1 (K1), R67.2
unnamed: D2.3 (K2), R66.2
unnamed: D3.1 (K1), R69.2
unnamed: D3.3 (K2), R68.2
unnamed: D4.1 (K1), R71.2
unnamed: D4.3 (K2), R70.2
unnamed: D5.1 (K1), R51.2
unnamed: D5.3 (K2), R72.1
unnamed: D11.2 (A), R8.2
unnamed: D12.2 (A), JP7.2 (C), U4.3
unnamed: C78.1, C80.1, C83.1, D12.1 (K), U3.6 (V_BCKP), U4.4, U4.5 (V+)
unnamed: J1.L1, R6.1
unnamed: J1.L4, R7.1
unnamed: J2.2, U3.22 (JAM_IND)
unnamed: J2.4, U3.23 (3D_FIX)
unnamed: J3.1, R40.2, U8.31 (GPIOL_00_SS_N), U9.1 (~CS)
unnamed: C45.1, J3.3, R35.2, SW1.2, U8.35 (CRESET_N)
unnamed: J3.5, R32.2, U8.27 (TDI)
unnamed: J3.7, R33.2, U8.24 (TDO)
unnamed: J3.9, R31.2, U8.26 (TCK)
unnamed: J3.11, R34.2, U8.25 (TMS)
unnamed: J3.13, R43.2
unnamed: J4.A5 (CC1), R45.1
unnamed: J4.B5 (CC2), R44.1
unnamed: C54.1, J4.S1 (SHIELD), R50.1
unnamed: J9.2, U3.21 (GEOFENCE)
unnamed: JP6.1 (A), U3.14 (VDD_RF)
unnamed: JP6.2 (B), R13.2
unnamed: Q1.3 (D), R72.2
unnamed: Q1.1 (G), R36.2, R51.1, U8.34 (CDONE)
unnamed: C46.1, C47.1, C55.1, L2.2, U2.19 (ANA33VDD)
unnamed: R10.1, U2.38 (RX_CLK)
unnamed: R53.1, U2.20 (VREF)
unnamed: R14.2, R20.2, U3.17 (I2C_SCL)
unnamed: R15.2, R16.2, U3.16 (I2C_SDA)
unnamed: R38.1, U3.3 (RXD)
unnamed: R29.1, U3.2 (TXD)
unnamed: R58.1, R60.1, U6.6 (FB)
unnamed: L6.2, U6.3 (SW)
unnamed: U8.30 (GPIOL_01_CCK), U9.6 (SCK)
unnamed: R37.2, U8.32 (GPIOL_04_CSI)
unnamed: U8.29 (GPIOL_08_CDI0), U9.5 (SI/IO0)
unnamed: U8.28 (GPIOL_09_CDI1), U9.2 (SO/IO1)
unnamed: U8.75 (GPIOR_157_PLLIN), X2.3 (OUT)
unnamed: C31.1, C32.1, L5.2, U8.73 (VCCA_BR)
unnamed: C29.1, C30.1, L4.2, U8.2 (VCCA_TL)
unnamed: C27.1, C28.1, L3.2, U8.107 (VCCA_TR)
unnamed: R41.2, U9.7 (~HOLD/IO3)
unnamed: R42.2, U9.3 (~WP/IO2)
unnamed: C49.2, U10.15 (VDD33), U10.18 (ID)
unnamed: R47.1, U10.19 (RBIAS)
unnamed: C53.1, R73.2, U10.21 (REFCLK/XI), Y1.3
unnamed: R46.2, U10.17 (VBUS)
unnamed: C50.2, U10.23 (VDD18)
unnamed: C52.1, R73.1, U10.20 (XO), Y1.1
unnamed: R48.2, R49.2, U10.22 (~RESETB)
unnamed: R56.2, U6.5 (PG), U12.1 (EN)
unnamed: R59.1, R61.1, U12.6 (FB)
unnamed: L7.2, U12.3 (SW)
POWER_GOOD: R39.1, U4.6, U12.5 (PG)
SDRAM_A4: U1.29 (A4), U8.110 (GPIOR_87_CDI29)
SDRAM_A5: U1.30 (A5), U8.109 (GPIOR_88_CDI28)
SDRAM_DQ0: U1.2 (DQ0), U8.33 (GPIOL_05_CSO)
UART_RX: R16.1, R38.2, U8.42 (GPIOB_TXP04)
UART_TX: R20.1, R29.2, U8.43 (GPIOB_TXN04)
ULPI_CLK: U8.132 (GPIOL_74_PLLIN0), U10.2 (CLKOUT)
ULPI_DIR: U8.134 (GPIOL_73_EXTFB1_CDI15), U10.1 (DIR)
ULPI_NXT: U8.131 (GPIOL_75_PLLIN1), U10.3 (NXT)
ULPI_RSTb: R49.1, U8.138 (GPIOL_69_CBSEL1)
ULPI_STP: U8.135 (GPIOL_72_EXTFB0_CDI14), U10.24 (STP)

## Commit log

2023-11-21 block_diag.png: increased size
2024-01-08 trion-8 test board
2024-01-08 .gitignore: added *.lck files
2024-01-08 Fixed V1.0 errata
    - added feedback resistor for ulpi transceiver clock oscillator
    - removed SS_N connection
2024-01-14 sdram layout done - COMPLETE REWORK NEEDED
    cannot mix LVDS and GPIO banks due to too different timing
2024-01-16 layout finished; passed all checks...
2024-01-21 pcb: changed gerber output directory
2024-05-12 rerouted some SDRAM pins to 139,140,141,142,144
    Preparation for moving ULPI to free up some DDIO pins
    on the other side of the package...
2024-06-10 added ethernet phy
2024-06-11 Some BOM clarifications and updates
2024-06-15 part-info update
2024-06-16 updated R20 to 1M (100k proved to strong a pull-down)
2024-06-16 Added README.md
2024-06-16 README.md: typo
2024-06-16 Added block-diagrams
2024-06-29 Added Manufacturer + Part info for most components.
2024-06-30 PCB: updated silkscreen
    Enabled LED labeling, added some labels for connector pins
2024-07-27 Added GPS receiver; increased board size
    including battery supply; made board bigger
    and added edge connectors for ETH GPIO, PPS
    and antenna.
2024-08-07 updated PCB
2024-09-03 finalizing...
2024-09-03 renamed unused.kicad_sch -> gpio.kicad_sch
2024-09-03 renamed project trion-8-test -> tic-nic
2024-09-03 PCB: changed SMA footprint; removed paste
2024-09-29 bumped version to 2.1
    updated several values;
    * added AC-coupling cap on RF_IN
2024-09-29 ChangeLog: added
2024-09-29 reconnected fpgaGpio[0] from pin 36 -> 32 (REF_RES is *not* a GPIO!)
2024-09-29 changed direction of UART_TX/UART_RX symbols
    refer to Tx/Rx of the GPS module
2024-09-29 block_diag: updated; added GPS receiver
2024-10-06 small fixes; prettified the fab layer and added DNP on schematic
2024-10-17 more fab updates
